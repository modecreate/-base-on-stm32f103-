# Keil uVision project AS608.uvprojx, settings and files
target AS608 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AS608 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\SPI;..\MALLOC;..\USMART;..\HARDWARE\FLASH;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\HARDWARE\24CXX;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\USART2;..\HARDWARE\IIC;..\HARDWARE\AS608;..\HARDWARE\SG90;..\HARDWARE\PWM;..\HARDWARE\BEEP;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\portable\MemMang;..\SYSTEM\usart3;..\HARDWARE\LCD180;..\HARDWARE\LCD180DEMO;..\HARDWARE\LCD180GUI;..\HARDWARE\DHT11;..\HARDWARE\LCD180SPI;..\HARDWARE\ADC;..\HARDWARE\LCD;..\HARDWARE\TPAD;..\HARDWARE\EXTI;..\HARDWARE\OV7725;..\HARDWARE\LED;..\HARDWARE\SDIO;..\HARDWARE\W25QXX;..\FATFS;..\TEXT;..\PICTURE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LCD180/: lcd180.c
    ../HARDWARE/LCD180GUI/: GUI.c
    ../HARDWARE/LCD180SPI/: LCD180SPI.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/OV7725/: ov7725.c sccb.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart3/: usart3.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_sdio.c
  group MALLOC
    ../MALLOC/: malloc.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: README.TXT
  group FreeRTOS_CORE
    ../FreeRTOS/sources/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PROTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
